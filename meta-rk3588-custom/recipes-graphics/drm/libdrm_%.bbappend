# Keep DRM tests (modetest); skip unused GPU backends on RK3588.
PACKAGECONFIG = "tests install-test-programs"
